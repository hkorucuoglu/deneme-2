# Keil uVision project ODEV-1.uvproj, settings and files
target Proje odevi (MCS-51)
  device: ADuC841 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(12000000) DPX MODAB2
  output: ODEV-1
  c flags: Optimize=8 SizeSpeed=1
  group User folder
    ./: Main.a51
